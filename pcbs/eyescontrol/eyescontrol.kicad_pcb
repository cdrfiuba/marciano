# Repository cdrfiuba/marciano

## KiCad design pcbs/eyescontrol/eyescontrol.kicad_pcb

Parts:
C1, C2, C4: 100n; C_Rect_L4_W2.5_P2.5
C3, C5: 15p; C_Rect_L4_W2.5_P2.5
C6: 33m; C_Radial_D8_L13_P3.8
IC1: ATMEGA88-P; DIP-28__300
P1: EYES; Pin_Header_Straight_2x05
P2: PROG_MICRO; Pin_Header_Straight_2x03
P3: CONN_01X04; Socket_Strip_Straight_1x04
R1: 10k; Resistor_Horizontal_RM10mm
SW1: SW_PUSH; SW_PUSH_SMALL_m
Y1: 18.432 MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C1.1, C6.1, IC1.7 (VCC), IC1.20 (AVCC), P1.2, P2.2, P3.1, R1.1
/BLANK: IC1.16 ((PCINT2/OC1B/~SS~)PB2), P1.9
/DCPRG: IC1.6 ((PCINT20/XCK/T0)PD4), P1.8
/EYE-RX: IC1.2 ((PCINT16/RXD)PD0), P3.2
/EYE-TX: IC1.3 ((PCINT17/TXD)PD1), P3.3
/GSCLK: IC1.14 ((PCINT0/CLKO/ICP1)PB0), P1.6
/MISO: IC1.18 ((PCINT4/MISO)PB4), P2.1
/MOSI: IC1.17 ((PCINT3/OC2/MOSI)PB3), P1.3, P2.4
/RST: C4.1, IC1.1 ((PCINT14/~RESET~)PC6), P2.5, R1.2, SW1.1
/SCK: IC1.19 ((PCINT5/SCK)PB5), P1.5, P2.3
/VPRG: IC1.13 ((PCINT23/AIN1)PD7), P1.1
/XLAT: IC1.15 ((PCINT1/OC1A)PB1), P1.7
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, IC1.8 (GND), IC1.22 (GND), P1.10, P2.6, P3.4, SW1.2
unnamed: C2.1, IC1.21 (AREF)
unnamed: C3.1, IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), Y1.1
unnamed: C5.1, IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), Y1.2

Notes on the sheet:
Control de los ojos
Conector para los ojos

Board: 2 copper layers, 40.6 x 43.2 mm, 13 parts (0 on the bottom side), 16 nets.

## KiCad design pcbs/control_remoto/controlremoto.kicad_pcb

Parts:
C1, C2: 100u; C_Radial_D5_L6_P2.5
C3: 10u; C_Radial_D5_L6_P2.5
C4, C5: 100n; C_Rect_L7_W2_P5
C10: 1u; C_Rect_L18_W5_P15
J2: Jack-stereo-gnd; audio-jack-stereo
L1: 1u; Resistor_Horizontal_RM10mm
P1: CONN_BATT; molex_2_recto
P2: CONN_BTN00; Pin_Header_Straight_1x02
P3: CONN_BTN05; Pin_Header_Straight_1x02
P4: CONN_BTN01; Pin_Header_Straight_1x02
P5: CONN_BTN06; Pin_Header_Straight_1x02
P6: CONN_BTN02; Pin_Header_Straight_1x02
P7: CONN_BTN07; Pin_Header_Straight_1x02
P8: CONN_BTN03; Pin_Header_Straight_1x02
P9: CONN_BTN08; Pin_Header_Straight_1x02
P10: CONN_BTN04; Pin_Header_Straight_1x02
P11: CONN_BTN09; Pin_Header_Straight_1x02
P12: CONN_01X03; Socket_Strip_Straight_1x03
P13: DIPSWITCH; DIP-16__300_ELL
R1, R3: 2k2; Resistor_Horizontal_RM10mm
R2: inf; Resistor_Horizontal_RM10mm
R4: 2.2k; Resistor_Horizontal_RM10mm
R6: 1k; Resistor_Horizontal_RM10mm
R8: 10k; Resistor_Horizontal_RM10mm
R9, R10: 820; Resistor_Horizontal_RM10mm
RV1: 100K; Pin_Header_Straight_1x03
RV2: 100k; Pin_Header_Straight_1x03
SW1: ON/OFF; Pin_Header_Straight_1x02
U1: MMA7455L_DIP8; DIP-8__300_ELL
U2: PTN4050; PTN04050C-EUU
U3: MBED
U4: TL082; DIP-8__300_ELL
U5: ZIGBIT_DUAL_DIP; ZIGBIT_DIP_40

Connections:
+3V3: R1.1, R3.1, U1.1 (AVDD), U1.8 (DVDD), U3.40 (3.3V_Vout), U5.22 (D_VCC)
+5V: C2.1, L1.1, U2.4 (VO), U3.2 (Vin); also elsewhere on the board
+BATT: P1.2, SW1.1
/ACEL_INT1: U1.2 (INT1), U3.30 (rd/p30)
/ACEL_INT2: U1.3 (INT2), U3.29 (td/p29)
/BTN_00: P2.2, U3.15 (p15/AnalogIn)
/BTN_01: P4.2, U3.16 (p16/AnalogIn)
/BTN_02: P6.2, U3.17 (p17/AnalogIn)
/BTN_03: P8.2, U3.18 (p18/AnalogIn)
/BTN_04: P10.2, U3.11 (p11/mosi)
/BTN_05: P3.2, U3.26 (PwnOut/p26)
/BTN_06: P5.2, U3.25 (PwnOut/p25)
/BTN_07: P7.2, U3.24 (PwnOut/p24)
/BTN_08: P9.2, U3.23 (PwnOut/p23)
/BTN_09: P11.2, U3.22 (PwnOut/p22)
/DIPSW_1: P13.1, U5.4 (GPIO0)
/DIPSW_2: P13.2, U5.5 (GPIO1)
/DIPSW_3: P13.3, U5.6 (GPIO2)
/DIPSW_4: P13.4, U5.16 (GPIO6)
/DIPSW_5: P13.5, U5.17 (GPIO7)
/DIPSW_6: P13.6, U5.18 (GPIO3)
/DIPSW_7: P13.7, U5.33 (GPIO_1WR)
/DIPSW_8: P13.8, U5.38 (GPIO8)
/MIC: C5.2, R10.1, U3.19 (p19/AnalogIn)
/MicA: J2.2, P12.3
/MicB: J2.5, P12.1
/Parlante/IN: U3.21 (PwnOut/p21); also elsewhere on the board
/SCL: R1.2, U1.6 (SCL), U3.27 (rx/scl/p27)
/SDA: R3.2, U1.5 (SDA), U3.28 (tx/sda/p28)
/VCC2: C10.1, L1.2, R4.1, RV1.1, U4.8 (V+)
/ZB_RESET: U3.8 (p8), U5.8 (RESET)
/ZIGBIT_RX: U3.14 (p14/rx), U5.13 (UART_RXD)
/ZIGBIT_TX: U3.13 (p13/tx/sck), U5.12 (UART_TXD)
GND: C1.2, C2.2, C4.1, C5.1, C10.2, J2.1, P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.1, P8.1, P9.1, P10.1, P11.1, P13.9, P13.10, P13.11, P13.12, P13.13, P13.14, P13.15, P13.16, R2.2, RV1.3, U1.4 (GND), U1.7 (A0), U2.1 (GND), U3.1 (GND), U4.4 (V-), U5.21 (DGND), U5.32 (AGND); also elsewhere on the board
unnamed: C1.1, SW1.2, U2.2 (VI)
unnamed: C3.1, P12.2, R4.2
unnamed: C3.2, R6.2
unnamed: C4.2, R9.1, U4.5 (+)
unnamed: R2.1, U2.3 (Adj.)
unnamed: R6.1, R8.2, U4.2 (-)
unnamed: R8.1, RV2.1, RV2.2
unnamed: R9.2, RV2.3, U4.1
unnamed: R10.2, U4.6 (-), U4.7
unnamed: RV1.2, U4.3 (+)

Notes on the sheet:
RXD = TX
TXD = RX
BOTONES
ALIMENTACION
ACELEROMETRO
COMUNICACION
MICRO
MICROFONO
PARLANTE

Parts:
C6: 10u; C_Radial_D5_L6_P2.5
C7: 100n; C_Disc_D3_P2.5
C8: 47n; C_Disc_D3_P2.5
C9: 220u; C_Radial_D5_L6_P2.5
C11, C12: 33n; C_Disc_D3_P2.5
C13, C14: 1u; C_Disc_D3_P2.5
J1: JACK_TRS_6PINS; Pin_Header_Angled_1x06
L2, L3: 1u; Resistor_Horizontal_RM10mm
R7: 10; Resistor_Horizontal_RM10mm
R11, R12, R13, R14: 1k; Resistor_Horizontal_RM10mm
RV3: 10k; Pin_Header_Straight_1x03
U6: TL082; DIP-8__300_ELL
U7: LM386_mod; DIP-8__300_ELL

Connections:
+5V: L2.1, L3.1; also elsewhere on the board
/Parlante/IN: R13.2; also elsewhere on the board
/Parlante/VCC2: C14.1, L3.2, U7.6 (Pwr)
/Parlante/VCC3: C13.1, L2.2, U6.8 (V+)
GND: C7.1, C8.2, C11.2, C12.2, C13.2, C14.2, J1.1, R11.1, R12.1, RV3.3, U6.4 (V-), U7.2 (-), U7.4 (Gnd); also elsewhere on the board
unnamed: C6.1, U6.6 (-), U6.7
unnamed: C6.2, RV3.1
unnamed: C7.2, U7.7 (B)
unnamed: C8.1, R7.2
unnamed: C9.1, R7.1, U7.5
unnamed: C9.2, J1.2, J1.5
unnamed: C11.1, R13.1, U6.3 (+)
unnamed 47: C12.1, R14.1, U6.5 (+); also elsewhere on the board
unnamed: J1.3, R12.2
unnamed: J1.4, R11.2
unnamed 51: R14.2, U6.1, U6.2 (-); also elsewhere on the board
unnamed: RV3.2, U7.3 (+)

Notes on the sheet:
PARLANTE

Board: 2 copper layers, 175.5 x 61.0 mm, 56 parts (0 on the bottom side), 58 nets.

Other parts of the board:
R5: 1k; Resistor_Horizontal_RM10mm

Their connections:
unnamed 47: R5.1; also elsewhere on the board
unnamed 51: R5.2; also elsewhere on the board

## KiCad design pcbs/basicmother/basicmother.kicad_pcb

Board: 2 copper layers, 125.7 x 121.0 mm, 81 parts (4 on the bottom side), 80 nets.

Parts:
C1, C2, C6, C20: 100u; C_Radial_D5_L6_P2.5
C3, C14, C16: 100n; C_Disc_D3_P2.5
C4, C5: 22n; C_Rect_L7_W2_P5
C7, C10, C11, C19, C21: 10u; C_Radial_D5_L6_P2.5
C8, C9: 390n; C_Disc_D3_P2.5
C12, C13, C18: 1u; C_Rect_L18_W5_P15
C15: 10n; C_Disc_D3_P2.5
C17: 330 uF; C_Radial_D5_L6_P2.5
C22: 5.6n; C_Disc_D3_P2.5
C23: 3.3n; C_Disc_D3_P2.5
D1: LED; LED-5MM
IC1: DRV8843; HTSSOP28
L1, L2, L3: 1uH; Resistor_Horizontal_RM10mm
P1: ZIGBIT_DIP; DIP-16__300
P2: Eyes-comm; Socket_Strip_Straight_1x04
P3: L-MOTOR; Socket_Strip_Straight_1x02
P4: R-MOTOR; Socket_Strip_Straight_1x02
P5: SWITCH; Socket_Strip_Straight_1x02
P6: BATT; bornier2
P7: SPK1; Socket_Strip_Straight_1x02
P8: SPK2; Socket_Strip_Straight_1x02
P9, P10: mic_conn; Socket_Strip_Straight_1x02
P11: BATT; molex_2_recto
R1: 1k; Resistor_Horizontal_RM10mm
R2: 1.35k; Resistor_Horizontal_RM10mm
R3: 1.07k; Resistor_Horizontal_RM10mm
R4: 5.62k; Resistor_Horizontal_RM10mm
R5: 100k; Resistor_Horizontal_RM10mm
R6, R7, R8, R9, R10, R11: 22k; Resistor_Horizontal_RM10mm
R12, R13, R14, R20, R22, R23, R24, R25, R26, R27, R28: 10k; Resistor_Horizontal_RM10mm
R15, R16: .47; Resistor_Horizontal_RM15mm
R17: 1M; Resistor_Horizontal_RM10mm
R18, R19: 2.2k; Resistor_Horizontal_RM10mm
R21: 47k; Resistor_Horizontal_RM10mm
RV1, RV2: 50k; Socket_Strip_Straight_1x03
RV3, RV4, RV5, RV6: 100k; Socket_Strip_Straight_1x03
U1: ZIGBIT_DUAL_DIP; ZIGBIT_DIP_40
U2: MBED
U3: bluetooth-mod; Socket_Strip_Straight_2x17
U4: PTN4050; PTN04050C-EUU
U5: LMZ12002; PFM7
U6, U7: LM4950TS; TO-263
U8: LM324N; DIP-14__300_ELL

Connections:
+3V3: U1.22, U2.40, U3.12
+5V: C1.1, C5.2, C6.1, L3.1, P2.1, R4.1, R12.1, U2.2, U4.2, U5.7
+12V: C2.1, C3.1, L1.2, L2.2, U4.4
+15V: C7.1, C16.1, C17.1, IC1.4, IC1.11, P5.2, R5.1, R17.1, U5.1
+BATT: P5.1, P6.1, P11.1
/DIPSW_1: P1.1, U1.4
/DIPSW_2: P1.2, U1.5
/DIPSW_3: P1.3, U1.6
/DIPSW_4: P1.4, U1.16
/DIPSW_5: P1.5, U1.17
/DIPSW_6: P1.6, U1.18
/DIPSW_7: P1.7, U1.33
/DIPSW_8: P1.8, U1.38
/EYE-RX: P2.2, U2.9
/EYE-TX: P2.3, U2.10
/RXDBT: U2.28, U3.2
/TXDBT: U2.27, U3.1
/ZIGBIT_RESET: U1.8, U2.8
/ZIGBIT_RX: U1.13, U2.14
/ZIGBIT_TX: U1.12, U2.13
/microfono/Dif: R25.2, RV6.2, RV6.3, U8.8
/microfono/M1: R26.2, RV4.2, RV4.3, U8.1
/microfono/M2: R27.2, RV5.2, RV5.3, U8.7
/microfono/OUT: C22.2, U2.15, U8.13, U8.14
/microfono/VCC2: C18.1, L3.2, R18.1, R19.1, RV3.1, U8.4
/microfono/Vref: R21.2, RV3.2, U8.5, U8.10
/motordrv/INT33: C14.1, IC1.15, R13.1
/motordrv/IN_A1: IC1.21, U2.25
/motordrv/IN_A2: IC1.20, U2.26
/motordrv/IN_B1: IC1.22, U2.24
/motordrv/IN_B2: IC1.23, U2.23
/motordrv/MOUT_A1: IC1.5, P3.1
/motordrv/MOUT_A2: IC1.7, P3.2
/motordrv/MOUT_B1: IC1.10, P4.1
/motordrv/MOUT_B2: IC1.8, P4.2
/motordrv/~FAULT: IC1.18, U2.18
/motordrv/~RESET: IC1.16, U2.20
/motordrv/~SLEEP: IC1.17, U2.19
/sound/In: C8.2, C9.2, U2.21
/sound/~SHD: U2.30, U6.2, U7.2
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C10.2, C11.2, C12.1, C13.1, C14.2, C17.2, C18.2, C21.2, C23.2, D1.2, IC1.14, IC1.24, IC1.25, IC1.26, IC1.27, IC1.28, P1.9, P1.16, P2.4, P6.2, P9.2, P10.2, P11.2, R2.2, R3.2, R14.2, R15.1, R16.1, RV3.3, U1.21, U2.1, U3.13, U3.22, U4.1, U5.4, U6.4, U6.5, U6.10, U7.4, U7.5, U7.10, U8.11
unnamed: C4.1, U5.5
unnamed: C5.1, R3.1, R4.2, U5.6
unnamed: C8.1, R6.2
unnamed: C9.1, R7.2
unnamed: C10.1, U6.8
unnamed: C11.1, U7.8
unnamed: C12.2, L1.1, U6.6
unnamed: C13.2, L2.1, U7.6
unnamed: C15.1, IC1.2
unnamed: C15.2, IC1.1
unnamed: C16.2, IC1.3, R17.2
unnamed: C19.1, P9.1, R18.2
unnamed: C19.2, R21.1, U8.3
unnamed: C20.1, P10.1, R19.2
unnamed: C20.2, R20.2
unnamed: C21.1, R22.1
unnamed: C22.1, R25.1, R28.1
unnamed: C23.1, R28.2, U8.12
unnamed: D1.1, R1.2
unnamed: IC1.6, R15.2
unnamed: IC1.9, R16.2
unnamed: IC1.12, IC1.13, R13.2, R14.1
unnamed: IC1.19, R12.2
unnamed: P7.1, R8.1, R10.1, U6.3
unnamed: P7.2, RV1.1, RV1.2, U6.7
unnamed: P8.1, R9.1, R11.1, U7.3
unnamed: P8.2, RV2.1, RV2.2, U7.7
unnamed: R1.1, U3.24
unnamed: R2.1, U4.3
unnamed: R5.2, U5.2
unnamed: R8.2, RV1.3, U6.9
unnamed: R9.2, RV2.3, U7.9
unnamed: R6.1, R10.2, U6.1
unnamed: R7.1, R11.2, U7.1
unnamed: R20.1, R24.2, U8.6
unnamed: R22.2, R23.2, U8.2
unnamed: R23.1, RV4.1
unnamed: R24.1, RV5.1
unnamed: R26.1, R27.1, RV6.1, U8.9

## KiCad design pcbs/eyesunicolor/eyesunicolor.kicad_pcb

Board: 2 copper layers, 203.5 x 96.5 mm, 43 parts (9 on the bottom side), 51 nets.

Parts:
C1, C2: 100n; C1
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32: LED; LED-5MM
J1, J2: SUPP28; DIP-28__300_ELL
P1, P2, P3: CONN_5X2; PIN_ARRAY_5x2
R1, R3: 2.2k; R4-LARGE_PADS
R2, R4: 10k; R4-LARGE_PADS

Connections:
/BLANK_D: J2.23, P2.9, P3.9, R4.2
/BLANK_I: J1.23, P1.9, R2.2
/DCPRG_D: J2.19, P2.8, P3.8
/DCPRG_I: J1.19, P1.8
/GSCLK_D: J2.18, P2.6, P3.6
/GSCLK_I: J1.18, P1.6
/SCLK_D: J2.25, P2.5, P3.5
/SCLK_I: J1.25, P1.5
/SIN_D: J2.26, P2.3
/SIN_I: J1.26, P1.3
/SOUT_D: J2.17, P3.3
/VPRG_D: J2.27, P2.1, P3.1
/VPRG_I: J1.27, P1.1
/XLAT_D: J2.24, P2.7, P3.7
/XLAT_I: J1.24, P1.7
GND: C1.1, C2.1, J1.22, J2.22, P1.10, P2.10, P3.10, R1.1, R3.1
unnamed: J2.20, R3.2
unnamed: J1.20, R1.2
unnamed: D30.2, J2.13
unnamed: D1.2, J1.28
unnamed: D15.2, J1.14
unnamed: D11.2, J1.10
unnamed: D16.2, J1.15
unnamed: D4.2, J1.3
unnamed: D8.2, J1.7
unnamed: D6.2, J1.5
unnamed: D12.2, J1.11
unnamed: D14.2, J1.13
unnamed: D13.2, J1.12
unnamed: D10.2, J1.9
unnamed: D9.2, J1.8
unnamed: D7.2, J1.6
unnamed: D5.2, J1.4
unnamed: D3.2, J1.2
unnamed: D2.2, J1.1
unnamed: D23.2, J2.6
unnamed: D26.2, J2.9
unnamed: D29.2, J2.12
unnamed: D28.2, J2.11
unnamed: D17.2, J2.28
unnamed: D27.2, J2.10
unnamed: D18.2, J2.1
unnamed: D32.2, J2.15
unnamed: D31.2, J2.14
unnamed: D20.2, J2.3
unnamed: D21.2, J2.4
unnamed: D24.2, J2.7
unnamed: D25.2, J2.8
unnamed: D22.2, J2.5
unnamed: D19.2, J2.2
VCC: C1.2, C2.2, D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, D13.1, D14.1, D15.1, D16.1, D17.1, D18.1, D19.1, D20.1, D21.1, D22.1, D23.1, D24.1, D25.1, D26.1, D27.1, D28.1, D29.1, D30.1, D31.1, D32.1, J1.21, J2.21, P1.2, P2.2, P3.2, R2.1, R4.1

## Code that names these connections

File src/eyes/MatthewPandina/code/ch5/main.c:

#include <stdint.h>
#include <avr/io.h>
#include <avr/interrupt.h>

#define GSCLK_DDR DDRB
#define GSCLK_PORT PORTB
#define GSCLK_PIN PB0

#define SIN_DDR DDRB
#define SIN_PORT PORTB
#define SIN_PIN PB3

#define SCLK_DDR DDRB
#define SCLK_PORT PORTB
#define SCLK_PIN PB5

#define BLANK_DDR DDRB
#define BLANK_PORT PORTB
#define BLANK_PIN PB2

#define DCPRG_DDR DDRD
#define DCPRG_PORT PORTD
#define DCPRG_PIN PD4

#define VPRG_DDR DDRD
#define VPRG_PORT PORTD
#define VPRG_PIN PD7

#define XLAT_DDR DDRB
#define XLAT_PORT PORTB
#define XLAT_PIN PB1

#define TLC5940_N 1

#define setOutput(ddr, pin) ((ddr) |= (1 << (pin)))
#define setLow(port, pin) ((port) &= ~(1 << (pin)))
#define setHigh(port, pin) ((port) |= (1 << (pin)))
#define pulse(port, pin) do { \
                         	setHigh((port), (pin)); \
                         	setLow((port), (pin)); \
                         } while (0)
#define outputState(port, pin) ((port) & (1 << (pin)))

#if (12 * TLC5940_N > 255)
#define dcData_t uint16_t
#else
#define dcData_t uint8_t
#endif

#if (24 * TLC5940_N > 255)
#define gsData_t uint16_t
#else
#define gsData_t uint8_t
#endif

#define dcDataSize ((dcData_t)12 * TLC5940_N)
#define gsDataSize ((gsData_t)24 * TLC5940_N)

uint8_t dcData[12 * TLC5940_N] = {
	0b11111111,
	0b11111111,
	0b11111111,
	0b11111111,
	0b11111111,
	0b11111111,
	0b11111111,
	0b11111111,
	0b11111111,
	0b11111111,
	0b11111111,
	0b11111111,	
};

uint8_t gsData[24 * TLC5940_N] = {
	0b00000000,
	0b00000000,
	0b00000000,
	0b00000000,
	0b00000000,
	0b00000001,
	0b00000000,
	0b00100000,
	0b00000100,
	0b00000000,
	0b10000000,
	0b00010000,
	0b00000010,
	0b00000000,
	0b01000000,
	0b00001000,
	0b00000001,
	0b00000000,
	0b00100000,
	0b00000100,
	0b00000000,
	0b10000000,
	0b00001111,
	0b11111111,
};

void TLC5940_Init(void) {
	setOutput(GSCLK_DDR, GSCLK_PIN);
	setOutput(SCLK_DDR, SCLK_PIN);
	setOutput(DCPRG_DDR, DCPRG_PIN);
	setOutput(VPRG_DDR, VPRG_PIN);
	setOutput(XLAT_DDR, XLAT_PIN);
	setOutput(BLANK_DDR, BLANK_PIN);
	setOutput(SIN_DDR, SIN_PIN);
	
	setLow(GSCLK_DDR, GSCLK_PIN);
	setLow(SCLK_PORT, SCLK_PIN);
	setLow(DCPRG_PORT, DCPRG_PIN);
	setHigh(VPRG_PORT, VPRG_PIN);
	setLow(XLAT_PORT, XLAT_PIN);
	setHigh(BLANK_PORT, BLANK_PIN);

	// Enable SPI, Master, set clock rate fck/2
	SPCR = (1 << SPE) | (1 << MSTR);
	SPSR = (1 << SPI2X);

	// CTC with OCR0A as TOP
	TCCR0A = (1 << WGM01);
	// clk_io/1024 (From prescaler)
	TCCR0B = ((1 << CS02) | (1 << CS00));
	// Generate an interrupt every 4096 clock cycles
	OCR0A = 3;
	// Enable Timer/Counter0 Compare Match A interrupt
	TIMSK0 |= (1 << OCIE0A);
}

void TLC5940_ClockInDC(void) {
	setHigh(DCPRG_PORT, DCPRG_PIN);
	setHigh(VPRG_PORT, VPRG_PIN);
	
	for (dcData_t i = 0; i < dcDataSize; i++) {
		// Start transmission
		SPDR = dcData[i];
		// Wait for transmission complete
		while (!(SPSR & (1 << SPIF)));
	}
	pulse(XLAT_PORT, XLAT_PIN);
}

ISR(TIMER0_COMPA_vect) {
	static uint8_t xlatNeedsPulse = 0;
	
	setHigh(BLANK_PORT, BLANK_PIN);
	
	if (outputState(VPRG_PORT, VPRG_PIN)) {
		setLow(VPRG_PORT, VPRG_PIN);
		if (xlatNeedsPulse) {
			pulse(XLAT_PORT, XLAT_PIN);
			xlatNeedsPulse = 0;
		}
		pulse(SCLK_PORT, SCLK_PIN);
	} else if (xlatNeedsPulse) {
		pulse(XLAT_PORT, XLAT_PIN);
		xlatNeedsPulse = 0;
	}
	
	setLow(BLANK_PORT, BLANK_PIN);
	
	// Below this we have 4096 cycles to shift in the data for the next cycle
	for (gsData_t i = 0; i < gsDataSize; i++) {
		SPDR = gsData[i];
		while (!(SPSR & (1 << SPIF)));
	}
	xlatNeedsPulse = 1;
}

int main(void) {
	TLC5940_Init();
	TLC5940_ClockInDC();
	
	// Enable Global Interrupts
	sei();

	for (;;) {
	}
	
	return 0;
}

## Commit log

2013-07-13 agrego una version que usa el driver de leds
2013-08-23 Agrego el c?digo que hizo el sr. Matthew Padina sobre el TLC 5940
2013-08-23 cambios menores en el codigo
2013-08-24 Probe el ch3, cambio en Makefile y main.c
2013-08-31 Probamos el codigo del ch4, falta setear el FUSE del clock; Agregamos un resistencia al protoboard para bajar la intensidad de los leds; Modificamos el archivo main.c de los ch4 y ch3 para que se enc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
2013-09-07 Ajustamos los clocks, cambiamos los main.c de los capitulos 3 y 4
2013-09-14 Realizacion de esquematico
2013-09-21 Dise?o de placa. Acomodamos los leds.
2013-10-05 Termine la placa. Hay que optimizarla.
2013-10-19 Se termino el PCB del ojo izquierdo, se comenzo a trabajar con el ojo derecho
2013-10-26 Arme el pcb del ojo derecho. Falta termiar
2013-11-09 Intente terminar los ojos, pero no puedo co el ojo derecho. TERMINAR URGENTE
2013-11-16 Elimino archivos de backup y actualizo pcb y schm
2013-11-18 agrego los bordes y mas agujeros de montaje
2013-11-18 cambio la hoja a A4 y agrego rotulo
2013-11-18 agrego nuestros nombres en el PCB
2013-12-20 Agrego el codigo que funciona como test de los ojitos
2013-12-21 Arreglo la falla de VCC
2014-01-10 Creamos carpeta para nueva placa
2014-01-10 Agrego modulo mbed
2014-01-10 Agrego modulo de zigbit
2014-01-11 Esquematico para placa basicmother
2014-01-31 primera prueba de leds
2014-01-31 Te paso el esquematico :)
2014-02-01 Expresiones de los ojos
2014-02-08 Agrege nuevas expresiones, faltan probarlas.
2014-02-15 Terminando las expresiones con los ojos. Falta pestaneo
2014-04-26 Agrego el codigo de control del robot con libmanyuc
2014-04-26 Ajusto el clock y agrego una linea para que indique el tamanio del archivo
2014-04-26 Primera version de la placa madre y sigo agregando bibliotecas
2014-04-26 elimino archivos de cache
2014-04-26 emprolije eyes.c y el encabezado de la biblioteca de tlc5940
2014-04-26 Move eyes code to its directory.
    It also adds a main.c which listens to usart command and changes the
    eyes modes.
2014-04-26 Modes are not working.
2014-05-01 Ordenamos todos los modos de los ojos, falta corregir blink y tired
2014-05-01 Ajustamos el programa de los ojos e incluimos el codigo de cambiar modo de ojos al codigo de mbed car
2014-05-05 * Agregamos la biblioteca del acelerometro (Ariel) * Modificaciones previas a la feria del libro para controlar los ojos desde el control remoto
2014-10-07 Agrego un led de debug de serie y hago que los ojos se inicialicen en el modo 0.
2015-02-07 Actualizando la nueva placa base, falta el amplificador para el parlante
2015-03-11 actualizo la placa principal
2015-03-13 agrego archivos faltantes
2015-03-14 Dise?o del pcb del nuevo contro remoto
2015-03-14 Asociacion de componentes
2015-04-04 Actualizo esquematico de la placa principal y empiezo con el layout
2015-04-08 Actualic? el esquematico del control remoto
2015-04-11 Fin esquematico pcb control remoto
2015-04-11 Agrego parlante
2015-04-11 agrego algunos cambios en el control y casi termino la placa principal
2015-04-11 agrego la parte del microfono de la placa principal
2015-04-15 completo el esquematico del control y asigno footprints
2015-04-18 Placa Control remoto
2015-04-18 Actualizo el esquematico de la placa principal
2015-04-18 Actualizo el parlante
2015-04-19 Agrego la placa de control de los ojitos, separada de la principal
2015-04-19 saque el micro para el control de los ojitos y lo pase a una placa aparte, ademas agregue un doble microfono
2015-04-19 Placa control
2015-04-19 borro archivos de mas
2015-04-20 primera version del pcb de la placa principal, falta verificar footprints
2015-04-20 primera version del control, falta verificar footprint
2015-04-21 actualizo las 3 placas, revisar y mandar a fabricar
2015-04-25 Agrego primer version del sporte para control remoto
2015-04-25 Finished first version of the remote_control_holder
2015-04-25 Changed thickness of the remote_control_holder
2015-04-25 Add mbed version of marcian motherboard
2015-04-25 Faster acceleration
2015-04-26 Changed remote control holder for being more ergonomic, adjusted holes, buttons spacing and grip diameter
2015-04-26 Added the name 'MARCIANO' to the remote control grip part. Added needed files
2015-04-26 Adjusted hole size, added rounded corner. Mirrored for right hand too.
2015-11-07 actualizo el codigo de los ojitos
2015-11-07 ultimos cambios usando libmanyuc
2015-11-07 cambios hechos en las placas
2015-11-07 Create gh-pages branch via GitHub
